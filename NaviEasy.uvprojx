# Keil uVision project NaviEasy.uvprojx, settings and files
target NaviEasy (ARM-ADS)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: NaviEasy
  c flags: Optim=1 uC99=1
  c define: __CORTEX_M0, TARGET_LIKE_MBED, TARGET_CORTEX_M, TOOLCHAIN_ARM_MICRO, __MBED__=1, TARGET_STM, TARGET_STM32F0, TARGET_M0, TARGET_NUCLEO_F030R8, TARGET_STM32F030R8, TOOLCHAIN_ARM, TARGET_LIKE_CORTEX_M0, __ASSERT_MSG, NDEBUG
  c misc: --gnu --no_rtti --restrict --apcs=interwork -c -O3 -I"C:/Program Files/ARM/armcc_4.1_791/include" --split_sections --multibyte_chars --brief_diagnostics --library_type=microlib -D__ASSERT_MSG --no_depend_system_headers --md --cpu=Cortex-M0 -Otime --gnu --brief_diagnostics --library_type=microlib --apcs=interwork --cpu=Cortex-M0
  c include: .; mbed; mbed/TARGET_NUCLEO_F030R8; mbed/TARGET_NUCLEO_F030R8/TARGET_STM; mbed/TARGET_NUCLEO_F030R8/TARGET_STM/TARGET_STM32F0; mbed/TARGET_NUCLEO_F030R8/TARGET_STM/TARGET_STM32F0/TARGET_NUCLEO_F030R8; mbed/TARGET_NUCLEO_F030R8/TOOLCHAIN_ARM_MICRO
  asm define: __CORTEX_M0, TARGET_FF_ARDUINO, TARGET_FF_MORPHO, TARGET_LIKE_MBED, TARGET_CORTEX_M, TOOLCHAIN_ARM_MICRO, ARM_MATH_CM0, __MBED__=1, TARGET_STM, TARGET_STM32F0, TARGET_M0, TARGET_NUCLEO_F030R8, TARGET_STM32F030R8, TOOLCHAIN_ARM, MBED_BUILD_TIMESTAMP=1462954287, TARGET_LIKE_CORTEX_M0, __ASSERT_MSG
  asm misc: --brief_diagnostics -I"C:/Program Files/ARM/armcc_4.1_791/include" --apcs=interwork --cpu=Cortex-M0
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: mbed/TARGET_NUCLEO_F030R8/TOOLCHAIN_ARM_MICRO/stm32f0xx.sct
  link misc: --library_type=microlib
  group Include Files
    mbed/: AnalogIn.h analogin_api.h AnalogOut.h analogout_api.h buffer.h BusIn.h BusInOut.h BusOut.h CallChain.h CAN.h can_api.h can_helper.h CircularBuffer.h CThunk.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h dma_api.h Ethernet.h ethernet_api.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h gpio_api.h gpio_irq_api.h I2C.h i2c_api.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h lp_ticker_api.h mbed.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h pinmap.h platform.h port_api.h PortIn.h PortInOut.h PortOut.h PwmOut.h pwmout_api.h RawSerial.h rtc_api.h rtc_time.h semihost_api.h Serial.h serial_api.h SerialBase.h sleep_api.h SPI.h spi_api.h SPISlave.h Stream.h Ticker.h ticker_api.h Timeout.h Timer.h TimerEvent.h toolchain.h Transaction.h us_ticker_api.h wait_api.h
    mbed/TARGET_NUCLEO_F030R8/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis.h cmsis_nvic.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_sc000.h core_sc300.h hal_tick.h stm32_hal_legacy.h stm32f030x8.h stm32f0xx.h stm32f0xx_hal.h stm32f0xx_hal_adc.h stm32f0xx_hal_adc_ex.h stm32f0xx_hal_can.h stm32f0xx_hal_cec.h stm32f0xx_hal_comp.h stm32f0xx_hal_conf.h stm32f0xx_hal_cortex.h stm32f0xx_hal_crc.h stm32f0xx_hal_crc_ex.h stm32f0xx_hal_dac.h stm32f0xx_hal_dac_ex.h stm32f0xx_hal_def.h stm32f0xx_hal_dma.h stm32f0xx_hal_dma_ex.h stm32f0xx_hal_flash.h stm32f0xx_hal_flash_ex.h stm32f0xx_hal_gpio.h stm32f0xx_hal_gpio_ex.h stm32f0xx_hal_i2c.h stm32f0xx_hal_i2c_ex.h stm32f0xx_hal_i2s.h stm32f0xx_hal_irda.h stm32f0xx_hal_irda_ex.h stm32f0xx_hal_iwdg.h stm32f0xx_hal_pcd.h stm32f0xx_hal_pcd_ex.h stm32f0xx_hal_pwr.h stm32f0xx_hal_pwr_ex.h stm32f0xx_hal_rcc.h stm32f0xx_hal_rcc_ex.h stm32f0xx_hal_rtc.h stm32f0xx_hal_rtc_ex.h stm32f0xx_hal_smartcard.h stm32f0xx_hal_smartcard_ex.h stm32f0xx_hal_smbus.h stm32f0xx_hal_spi.h stm32f0xx_hal_spi_ex.h stm32f0xx_hal_tim.h stm32f0xx_hal_tim_ex.h stm32f0xx_hal_tsc.h stm32f0xx_hal_uart.h stm32f0xx_hal_uart_ex.h stm32f0xx_hal_usart.h stm32f0xx_hal_usart_ex.h stm32f0xx_hal_wwdg.h system_stm32f0xx.h
    mbed/TARGET_NUCLEO_F030R8/TARGET_STM/TARGET_STM32F0/TARGET_NUCLEO_F030R8/: device.h objects.h PeripheralNames.h PinNames.h PortNames.h
    mbed/TARGET_NUCLEO_F030R8/TARGET_STM/TARGET_STM32F0/: gpio_object.h PeripheralPins.h
  group Source Files
    mbed/TARGET_NUCLEO_F030R8/TOOLCHAIN_ARM_MICRO/: board.o hal_tick.o mbed.ar mbed_overrides.o retarget.o stm32f0xx_hal.o stm32f0xx_hal_adc.o stm32f0xx_hal_adc_ex.o stm32f0xx_hal_comp.o stm32f0xx_hal_cortex.o stm32f0xx_hal_crc.o stm32f0xx_hal_crc_ex.o stm32f0xx_hal_dma.o stm32f0xx_hal_flash.o stm32f0xx_hal_flash_ex.o stm32f0xx_hal_gpio.o stm32f0xx_hal_i2c.o stm32f0xx_hal_i2c_ex.o stm32f0xx_hal_iwdg.o stm32f0xx_hal_pwr.o stm32f0xx_hal_pwr_ex.o stm32f0xx_hal_rcc.o stm32f0xx_hal_rcc_ex.o stm32f0xx_hal_rtc.o stm32f0xx_hal_rtc_ex.o stm32f0xx_hal_spi.o stm32f0xx_hal_spi_ex.o stm32f0xx_hal_tim.o stm32f0xx_hal_tim_ex.o stm32f0xx_hal_uart.o stm32f0xx_hal_uart_ex.o stm32f0xx_hal_usart.o stm32f0xx_hal_wwdg.o sys.o
  group Application
    ./: main.cpp system_stm32f0xx.c startup_stm32f030x8.S cmsis_nvic.c Buffer.cpp BufferedSerial.cpp CC1101.cpp CommWifi.cpp FlashApp.cpp HighPowerReader.cpp Voice.cpp WifiObj.cpp WT588D.cpp SimpleKey.cpp BLE.cpp
